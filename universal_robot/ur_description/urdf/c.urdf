Commit message: controller updated

File: universal_robot/ur_description/urdf/c.urdf (robot description, URDF)
Before this commit: robot ur10.gripper, 22 links, 21 joints
Joints:
- joint world_joint: origin xyz=0.0 0.0 0.8 rpy=0.0 0.0 0.0 -> xyz=0.0 0.0 0.8 rpy=0.0 0.0 -1.6
